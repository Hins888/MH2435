# Keil uVision project Project.uvprojx, settings and files
target FLASH (6160000::V6.16::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00140000) IROM(0x08001000,0x01FFF000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Camera-CSI +hex
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 wLevel=3
  c misc: -include global-config.h -fdebug-macro
  c include: .;../../../../Component/Camera;../../../../Component/Camera/XS9950;../../../../Component/Display;../../../../Component/Display/DPI;../../../../Component/I2CPort;../../../../Libraries/CMSIS/Include;..\..\..\..\Libraries\Device\MegaHunt\mh2435\Include;../../../../Libraries\MH2435_StdPeriph_Driver\inc;../../App/Include;../../BSP/Include;../../Config
  asm include: .;../../../../Component/Camera;../../../../Component/Camera/GC0308;../../../../Component/Camera/OV5640;../../../../Component/Camera/SP1618;../../../../Component/Display;../../../../Component/Display/DBI;../../../../Component/Display/DBI/ILI9806;../../../../Component/Display/DPI;../../../../Component/Display/DSI;../../../../Component/Display/DSI/CO5300;../../../../Component/Display/DSI/EK79007;../../../../Component/Display/DSI/GC9503V;../../../../Component/Display/DSI/GC9C01;../../../../Component/Display/DSI/HX8394F;../../../../Component/Display/DSI/IL79451A;../../../../Component/Display/DSI/ILI9806E;../../../../Component/Display/DSI/ILI9881C;../../../../Component/Display/DSI/JD9365DA;../../../../Component/Display/DSI/JD9852;../../../../Component/Display/DSI/NT35510;../../../../Component/Display/DSI/NV3049ET;../../../../Component/Display/DSI/ST7701S;../../../../Component/Display/DSI/ST7703;../../../../Component/Display/DSI/ST77922;../../../../Component/Display/DSI/ST7797;../../../../Component/I2CPort;../../../../Libraries/CMSIS/Include;../../../../Libraries/Device/Megahunt/MH245x/Include;../../../../Libraries/MH245x_StdPeriph_Driver/inc;../../../../Libraries/component-Display-DBI-All;../../../../Libraries/component-Display-DPI-All;../../../../Libraries/component-Display-DSI-All;../../../../Libraries/component-SDRAM;../../../../Libraries/posoc;../../App/Include;../../BSP/Include;../../Config
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0x1fff000
  memory RVCT9: RAM 0x20000000 size 0x140000
  scatter file: ARMClang.sct
  group config
    ../../Config/: global-config.h
    ./: memory.h
  group Camera-CSI
    ../../App/Source/: App.c
  group bsp
    ../../BSP/Source/: DisplayBSP.c DPI-DisplayBSP.c CameraBSP.c SDRAMBSP.c
  group component
    ../../../../Component/Display/: Display.c
    ../../../../Component/Display/DPI/: DisplayDPI.c
    ../../../../Component/I2CPort/: I2CPort.c
    ../../../../Component/Camera/: Camera.c
    ../../../../Component/Camera/XS9950/: XS9950.c
  group target-soc
    ../../../../Libraries/Device/Megahunt/mh2435/Source/: startup_mh2435.c system_mh2435.c
  group peripheral
    ../../../../Libraries/MH2435_StdPeriph_Driver/src/: peripheral.c mh2435_sysctrl.c mh2435_gpio.c mh2435_ltdc.c mh2435_i2c.c mh2435_dma.c mh2435_tim.c mh2435_csi.c mh2435_sdram.c
