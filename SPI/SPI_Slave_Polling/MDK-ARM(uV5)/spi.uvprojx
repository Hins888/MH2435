# Keil uVision project spi.uvprojx, settings and files
target FLASH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: spi +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\Device\MegaHunt\MH2435\Include;..\..\..\..\Libraries\MH2435_StdPeriph_Driver\inc;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0xa000
  group mdk-arm
    ../../../../Libraries/Device/MegaHunt/MH2435/Source/ARM/: startup_mh2435.s
    ../../../../Libraries/Device/MegaHunt/MH2435/Source/: system_mh2435.c
  group mh-drivers
    ../../../../Libraries/MH2435_StdPeriph_Driver/src/: mh2435_gpio.c mh2435_spi.c mh2435_usart.c mh2435_sysctrl.c peripheral.c mh2435_misc.c mh2435_dma.c
  group user
    ../user/: main.c
    ../user/usart/: bsp_debug_usart.c
    ../user/spi/: bsp_spi.c
